<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BLE_SensorDemo_BlueMSapp.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>BLE_SensorDemo_BlueMSapp</project>
                <configuration>HigherApp_OTA</configuration>
            </member>
            <member>
                <project>BLE_SensorDemo_BlueMSapp</project>
                <configuration>LowerApp_OTA</configuration>
            </member>
            <member>
                <project>BLE_SensorDemo_BlueMSapp</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>BLE_SensorDemo_BlueMSapp</project>
                <configuration>Use_OTA_ServiceManager</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
