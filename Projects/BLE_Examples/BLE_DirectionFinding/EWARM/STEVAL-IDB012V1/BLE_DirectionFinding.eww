<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BLE_DirectionFinding.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>BLE_DirectionFinding</project>
                <configuration>Tag</configuration>
            </member>
            <member>
                <project>BLE_DirectionFinding</project>
                <configuration>Locator</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
