<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DTM.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>DTM</project>
                <configuration>UART</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>UART_FOR_UPDATER</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>UART_WITH_UPDATER</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>SPI</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>SPI_FOR_UPDATER</configuration>
            </member>
            <member>
                <project>DTM</project>
                <configuration>SPI_WITH_UPDATER</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
