<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BLE_StaticStack.ewp</path>
  </project>
<batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
    <member>
        <project>BLE_StaticStack</project>
      <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



