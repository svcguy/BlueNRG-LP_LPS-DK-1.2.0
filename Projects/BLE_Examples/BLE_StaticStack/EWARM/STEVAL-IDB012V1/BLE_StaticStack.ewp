# IAR project BLE_StaticStack.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: BlueNRG-332 ST BlueNRG-332
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; CONFIG_DEVICE_BLUENRG_LPS; SUPPRESS_CONFIG_HW_WARNINGS; STEVAL_IDB012V1; RESET_MANAGER_SIZE=0x27800; BLE_STACK_CUSTOM_CONF
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\PKAMGR\Inc; ..\..\..\..\..\Middlewares\ST\RNGMGR\Inc; ..\..\..\..\..\Middlewares\ST\AESMGR\Inc; ..\..\..\..\..\Middlewares\ST\BLECNTR\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\BSP\Inc; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc\Common; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc\AES; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static_stack
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_StaticStack.hex
  postbuild: "..\..\..\..\..\Utility\create_sym_lib.exe" --symbols "..\..\sym_export.txt" --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks "$TARGET_PATH$" "..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static_stack\libbluenrg_lps_static_stack.a"
  ILINK.IlinkOutputFile: BLE_StaticStack.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=0x27800
  ILINK.IlinkIcfFile: BlueNRG_LPS.icf
  ILINK.IlinkExtraOptions: --use_optimized_variants no
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Basic (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; CONFIG_DEVICE_BLUENRG_LPS; SUPPRESS_CONFIG_HW_WARNINGS; STEVAL_IDB012V1; RESET_MANAGER_SIZE=0x18000; BLE_STACK_BASIC_CONF; CONFIG_NUM_MAX_LINKS=1
  OBJCOPY.OOCOutputFile: BLE_StaticStack_Basic.hex
  postbuild: "..\..\..\..\..\Utility\create_sym_lib.exe" --symbols "..\..\sym_export.txt" --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks "$TARGET_PATH$" "..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static_stack\libbluenrg_lps_static_stack_basic.a"
  ILINK.IlinkOutputFile: BLE_StaticStack_Basic.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=0x18000
configuration OTA_BTL_ResetManager (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: BLE_StaticStack_OTA_BTL_ResetManager.hex
  postbuild: "..\..\..\..\..\Utility\create_sym_lib.exe" --symbols "..\..\sym_export.txt" --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks "$TARGET_PATH$" "..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static_stack\libbluenrg_lps_static_stack_rstmngr.a"
  ILINK.IlinkOutputFile: BLE_StaticStack_OTA_BTL_ResetManager.out
configuration OTA_BTL_ResetManager_Basic (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: BLE_StaticStack_OTA_BTL_ResetManager_Basic.hex
  postbuild: "..\..\..\..\..\Utility\create_sym_lib.exe" --symbols "..\..\sym_export.txt" --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks "$TARGET_PATH$" "..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static_stack\libbluenrg_lps_static_stack_rstmngr_basic.a"
  ILINK.IlinkOutputFile: BLE_StaticStack_OTA_BTL_ResetManager_Basic.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=0x18000
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: startup_BlueNRG_LP.c system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_vtimer.c rf_driver_ll_flash.c rf_driver_ll_pka_v7c.c rf_driver_ll_timer.c
  group Example/User
    ../../src/: bluenrg_lp_cmd_if.c bluenrg_lp_ev_if.c Reset_Manager.c rf_device_it.c
    ../../../BLE_OTA_ResetManager/Src/: OTA_ResetManager_main.c
  group Middlewares/AES
    ../../../../../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    ../../../../../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    ../../../../../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lps.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/RNG
    ../../../../../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
