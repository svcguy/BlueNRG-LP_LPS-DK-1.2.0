<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BLE_SerialPort_MasterSlave_NWK.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>BLE_SerialPort_MasterSlave_NWK</project>
                <configuration>BLE_SerialPort_MasterSlave_NWK_SPI</configuration>
            </member>
            <member>
                <project>BLE_SerialPort_MasterSlave_NWK</project>
                <configuration>BLE_SerialPort_MasterSlave_NWK_UART</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
