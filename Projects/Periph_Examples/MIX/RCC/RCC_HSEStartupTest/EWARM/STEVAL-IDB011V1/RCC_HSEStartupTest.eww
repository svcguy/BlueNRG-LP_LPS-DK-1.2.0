<workspace>
  <project>
    <path>$WS_DIR$\RCC_HSEStartupTest.ewp</path>
  </project>
  <batchBuild />
</workspace>