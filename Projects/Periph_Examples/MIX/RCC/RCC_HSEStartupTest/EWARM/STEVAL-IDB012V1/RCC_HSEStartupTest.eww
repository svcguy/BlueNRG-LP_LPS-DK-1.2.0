<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RCC_HSEStartupTest.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



