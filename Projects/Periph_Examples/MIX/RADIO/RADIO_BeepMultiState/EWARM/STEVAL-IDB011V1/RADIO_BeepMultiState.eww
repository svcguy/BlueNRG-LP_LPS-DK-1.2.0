<workspace>
  <project>
    <path>$WS_DIR$\RADIO_BeepMultiState.ewp</path>
  </project>
  <batchBuild />
</workspace>