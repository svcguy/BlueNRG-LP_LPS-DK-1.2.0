<workspace>
  <project>
    <path>$WS_DIR$\RADIO_Sleep.ewp</path>
  </project>
  <batchBuild />
</workspace>