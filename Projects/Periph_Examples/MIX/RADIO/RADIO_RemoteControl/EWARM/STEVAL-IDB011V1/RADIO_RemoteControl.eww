<workspace>
  <project>
    <path>$WS_DIR$\RADIO_RemoteControl.ewp</path>
  </project>
  <batchBuild />
</workspace>