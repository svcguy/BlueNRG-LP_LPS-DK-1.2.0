# IAR project RADIO_OTA_RM.ewp, settings and files
configuration Client (ARM)
  General.OGChipSelectEditMenu: BlueNRG-332 ST BlueNRG-332
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; _DEBUG; STEVAL_IDB012V1; CONFIG_OTA_SERVICE_MANAGER; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RADIO_OTA_RM_Client.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_OTA_RM_Client.bin"
  ILINK.IlinkOutputFile: RADIO_OTA_RM_Client.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=0x2800
  ILINK.IlinkIcfFile: BlueNRG_LPS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Server_Ymodem (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; SERVER_YMODEM; STEVAL_IDB012V1; _DEBUG; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  OBJCOPY.OOCOutputFile: RADIO_OTA_RM_Server_Ymodem.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_OTA_RM_Server_Ymodem.bin"
  ILINK.IlinkOutputFile: RADIO_OTA_RM_Server_Ymodem.out
configuration Server_FixedImage (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: RADIO_OTA_RM_Server_FixedImage.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_OTA_RM_Server_FixedImage.bin"
  ILINK.IlinkOutputFile: RADIO_OTA_RM_Server_FixedImage.out
  group Application/User
    ../../Src/: binary_image_txrx_example.c rf_device_it.c RADIO_OTAClient_main.c RADIO_OTAServer_main.c RADIO_OTAServerFixedImage_main.c ymodem.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Drivers/Peripheral_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_radio_2g4.c rf_driver_hal_vtimer.c rf_driver_ll_flash.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_timer.c
  group Hal
    ../../../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c gp_timer.c osal.c
