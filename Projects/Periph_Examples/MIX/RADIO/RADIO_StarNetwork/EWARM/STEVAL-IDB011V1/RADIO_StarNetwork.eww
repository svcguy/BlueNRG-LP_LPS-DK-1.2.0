<workspace>
  <project>
    <path>$WS_DIR$\RADIO_StarNetwork.ewp</path>
  </project>
  <batchBuild />
</workspace>