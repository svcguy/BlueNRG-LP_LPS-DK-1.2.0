<workspace>
  <project>
    <path>$WS_DIR$\RADIO_Sniffer.ewp</path>
  </project>
  <batchBuild />
</workspace>