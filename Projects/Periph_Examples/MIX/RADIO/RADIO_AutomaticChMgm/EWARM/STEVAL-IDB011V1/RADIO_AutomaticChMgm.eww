<workspace>
  <project>
    <path>$WS_DIR$\RADIO_AutomaticChMgm.ewp</path>
  </project>
  <batchBuild />
</workspace>