<workspace>
  <project>
    <path>$WS_DIR$\RADIO_SnifferMultiState.ewp</path>
  </project>
  <batchBuild />
</workspace>