<workspace>
  <project>
    <path>$WS_DIR$\RADIO_Throughput.ewp</path>
  </project>
  <batchBuild />
</workspace>