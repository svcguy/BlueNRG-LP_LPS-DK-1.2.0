<workspace>
  <project>
    <path>$WS_DIR$\RADIO_Beep.ewp</path>
  </project>
  <batchBuild />
</workspace>