<workspace>
  <project>
    <path>$WS_DIR$\SPI_Polling_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>