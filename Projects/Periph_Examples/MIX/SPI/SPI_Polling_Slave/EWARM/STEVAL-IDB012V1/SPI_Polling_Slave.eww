<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SPI_Polling_Slave.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



