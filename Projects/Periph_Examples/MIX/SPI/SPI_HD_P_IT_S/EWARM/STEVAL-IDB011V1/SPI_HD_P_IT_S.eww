<workspace>
  <project>
    <path>$WS_DIR$\SPI_HD_P_IT_S.ewp</path>
  </project>
  <batchBuild />
</workspace>