<workspace>
  <project>
    <path>$WS_DIR$\SPI_HD_P_IT_M.ewp</path>
  </project>
  <batchBuild />
</workspace>