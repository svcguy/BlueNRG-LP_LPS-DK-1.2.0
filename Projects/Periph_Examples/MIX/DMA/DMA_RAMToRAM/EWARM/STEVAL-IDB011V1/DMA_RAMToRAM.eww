<workspace>
  <project>
    <path>$WS_DIR$\DMA_RAMToRAM.ewp</path>
  </project>
  <batchBuild />
</workspace>