<workspace>
  <project>
    <path>$WS_DIR$\MICRO_Hello_World.ewp</path>
  </project>
  <batchBuild />
</workspace>