<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MICRO_Hello_World.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



