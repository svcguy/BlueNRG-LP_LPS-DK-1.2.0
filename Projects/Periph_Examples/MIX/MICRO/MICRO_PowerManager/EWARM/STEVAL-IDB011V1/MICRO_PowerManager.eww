<workspace>
  <project>
    <path>$WS_DIR$\MICRO_PowerManager.ewp</path>
  </project>
  <batchBuild />
</workspace>