<workspace>
  <project>
    <path>$WS_DIR$\UART_TxPolling_RxIT.ewp</path>
  </project>
  <batchBuild />
</workspace>