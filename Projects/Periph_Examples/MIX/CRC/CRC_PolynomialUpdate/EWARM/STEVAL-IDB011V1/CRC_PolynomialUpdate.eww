<workspace>
  <project>
    <path>$WS_DIR$\CRC_PolynomialUpdate.ewp</path>
  </project>
  <batchBuild />
</workspace>