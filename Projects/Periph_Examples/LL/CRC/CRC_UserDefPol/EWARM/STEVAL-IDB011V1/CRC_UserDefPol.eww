<workspace>
  <project>
    <path>$WS_DIR$\CRC_UserDefPol.ewp</path>
  </project>
  <batchBuild />
</workspace>