<workspace>
  <project>
    <path>$WS_DIR$\CRC_CalculateCheck.ewp</path>
  </project>
  <batchBuild />
</workspace>