<workspace>
  <project>
    <path>$WS_DIR$\CORTEX_MPU.ewp</path>
  </project>
  <batchBuild />
</workspace>