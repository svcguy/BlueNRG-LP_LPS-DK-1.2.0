<workspace>
  <project>
    <path>$WS_DIR$\SPI_HD_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>