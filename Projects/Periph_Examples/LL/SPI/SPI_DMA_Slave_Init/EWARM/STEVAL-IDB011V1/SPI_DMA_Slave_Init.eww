<workspace>
  <project>
    <path>$WS_DIR$\SPI_DMA_Slave_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>