<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SPI_DMA_Master_Init.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



