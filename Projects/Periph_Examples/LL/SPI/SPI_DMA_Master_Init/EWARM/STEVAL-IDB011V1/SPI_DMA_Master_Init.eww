<workspace>
  <project>
    <path>$WS_DIR$\SPI_DMA_Master_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>