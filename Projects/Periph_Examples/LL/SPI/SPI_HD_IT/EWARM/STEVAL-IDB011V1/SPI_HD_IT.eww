<workspace>
  <project>
    <path>$WS_DIR$\SPI_HD_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>