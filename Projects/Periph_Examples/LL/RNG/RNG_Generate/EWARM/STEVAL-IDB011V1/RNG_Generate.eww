<workspace>
  <project>
    <path>$WS_DIR$\RNG_Generate.ewp</path>
  </project>
  <batchBuild />
</workspace>