<workspace>
  <project>
    <path>$WS_DIR$\EXTI_ToggleLedOnIT.ewp</path>
  </project>
  <batchBuild />
</workspace>