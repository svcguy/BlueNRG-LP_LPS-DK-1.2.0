<workspace>
  <project>
    <path>$WS_DIR$\RCC_OutputMCO.ewp</path>
  </project>
  <batchBuild />
</workspace>