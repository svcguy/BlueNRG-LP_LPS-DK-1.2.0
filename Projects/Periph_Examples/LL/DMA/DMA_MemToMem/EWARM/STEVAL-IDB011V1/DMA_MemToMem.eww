<workspace>
  <project>
    <path>$WS_DIR$\DMA_MemToMem.ewp</path>
  </project>
  <batchBuild />
</workspace>