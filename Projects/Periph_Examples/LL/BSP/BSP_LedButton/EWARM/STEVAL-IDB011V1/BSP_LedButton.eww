<workspace>
  <project>
    <path>$WS_DIR$\BSP_LedButton.ewp</path>
  </project>
  <batchBuild />
</workspace>