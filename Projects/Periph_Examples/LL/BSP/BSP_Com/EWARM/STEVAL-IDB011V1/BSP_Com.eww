<workspace>
  <project>
    <path>$WS_DIR$\BSP_Com.ewp</path>
  </project>
  <batchBuild />
</workspace>