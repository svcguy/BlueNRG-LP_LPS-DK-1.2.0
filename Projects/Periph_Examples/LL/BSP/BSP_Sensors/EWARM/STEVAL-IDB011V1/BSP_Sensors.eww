<workspace>
  <project>
    <path>$WS_DIR$\BSP_Sensors.ewp</path>
  </project>
  <batchBuild />
</workspace>