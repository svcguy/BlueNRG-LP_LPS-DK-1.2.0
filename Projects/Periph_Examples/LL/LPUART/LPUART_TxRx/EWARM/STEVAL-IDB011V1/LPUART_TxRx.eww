<workspace>
  <project>
    <path>$WS_DIR$\LPUART_TxRx.ewp</path>
  </project>
  <batchBuild />
</workspace>