<workspace>
  <project>
    <path>$WS_DIR$\IWDG_Refresh.ewp</path>
  </project>
  <batchBuild />
</workspace>