<workspace>
  <project>
    <path>$WS_DIR$\USART_HFC_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>