<workspace>
  <project>
    <path>$WS_DIR$\USART_TxRx_Inverted.ewp</path>
  </project>
  <batchBuild />
</workspace>