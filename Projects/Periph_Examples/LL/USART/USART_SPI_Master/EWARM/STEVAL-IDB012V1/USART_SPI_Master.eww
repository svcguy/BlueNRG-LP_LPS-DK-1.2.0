<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USART_SPI_Master.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



