<workspace>
  <project>
    <path>$WS_DIR$\USART_SPI_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>