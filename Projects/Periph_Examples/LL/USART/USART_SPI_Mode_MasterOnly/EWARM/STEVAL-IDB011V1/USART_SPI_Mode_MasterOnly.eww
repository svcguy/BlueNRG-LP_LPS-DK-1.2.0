<workspace>
  <project>
    <path>$WS_DIR$\USART_SPI_Mode_MasterOnly.ewp</path>
  </project>
  <batchBuild />
</workspace>