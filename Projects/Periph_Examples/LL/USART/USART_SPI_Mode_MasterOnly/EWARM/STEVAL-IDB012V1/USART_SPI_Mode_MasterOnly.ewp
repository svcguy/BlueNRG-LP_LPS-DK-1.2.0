# IAR project USART_SPI_Mode_MasterOnly.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-332 ST BlueNRG-332
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB012V1; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ../../Inc; ../../../../../../../Drivers/Peripherals_Drivers/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/ST/hal/Inc; ../../../../../../../Drivers/BSP/Inc; ../../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver; ../../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART_SPI_Mode_MasterOnly.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\USART_SPI_Mode_MasterOnly.bin"
  ILINK.IlinkOutputFile: USART_SPI_Mode_MasterOnly.out
  ILINK.IlinkIcfFile: BlueNRG_LPS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Src/: rf_device_it.c USART_SPI_Mode_MasterOnly_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_gpio.c rf_driver_ll_pwr.c rf_driver_ll_rcc.c rf_driver_ll_usart.c rf_driver_ll_utils.c
