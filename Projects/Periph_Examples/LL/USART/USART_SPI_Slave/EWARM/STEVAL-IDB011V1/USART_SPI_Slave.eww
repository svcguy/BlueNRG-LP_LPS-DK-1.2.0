<workspace>
  <project>
    <path>$WS_DIR$\USART_SPI_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>