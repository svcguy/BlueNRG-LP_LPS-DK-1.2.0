<workspace>
  <project>
    <path>$WS_DIR$\USART_Tx_IT_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>