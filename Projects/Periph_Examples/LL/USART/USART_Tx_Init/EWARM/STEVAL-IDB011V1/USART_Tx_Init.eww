<workspace>
  <project>
    <path>$WS_DIR$\USART_Tx_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>