<workspace>
  <project>
    <path>$WS_DIR$\USART_Rx_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>