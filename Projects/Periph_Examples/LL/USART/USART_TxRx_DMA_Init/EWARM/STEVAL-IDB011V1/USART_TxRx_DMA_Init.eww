<workspace>
  <project>
    <path>$WS_DIR$\USART_TxRx_DMA_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>