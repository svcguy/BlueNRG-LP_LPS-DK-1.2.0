<workspace>
  <project>
    <path>$WS_DIR$\TIM_PWMOutput_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>