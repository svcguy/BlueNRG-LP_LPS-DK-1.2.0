<workspace>
  <project>
    <path>$WS_DIR$\TIM_Input.ewp</path>
  </project>
  <batchBuild />
</workspace>