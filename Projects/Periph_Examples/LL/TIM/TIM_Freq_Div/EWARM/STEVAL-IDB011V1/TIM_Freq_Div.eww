<workspace>
  <project>
    <path>$WS_DIR$\TIM_Freq_Div.ewp</path>
  </project>
  <batchBuild />
</workspace>