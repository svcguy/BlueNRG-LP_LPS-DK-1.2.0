<workspace>
  <project>
    <path>$WS_DIR$\TIM_OnePulse_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>