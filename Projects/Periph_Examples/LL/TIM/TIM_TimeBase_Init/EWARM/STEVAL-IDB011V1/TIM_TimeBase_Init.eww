<workspace>
  <project>
    <path>$WS_DIR$\TIM_TimeBase_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>