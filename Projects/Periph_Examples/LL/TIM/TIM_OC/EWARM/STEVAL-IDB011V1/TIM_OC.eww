<workspace>
  <project>
    <path>$WS_DIR$\TIM_OC.ewp</path>
  </project>
  <batchBuild />
</workspace>