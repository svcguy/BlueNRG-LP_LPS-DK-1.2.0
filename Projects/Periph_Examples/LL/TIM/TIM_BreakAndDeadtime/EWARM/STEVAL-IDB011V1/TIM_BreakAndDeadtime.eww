<workspace>
  <project>
    <path>$WS_DIR$\TIM_BreakAndDeadtime.ewp</path>
  </project>
  <batchBuild />
</workspace>