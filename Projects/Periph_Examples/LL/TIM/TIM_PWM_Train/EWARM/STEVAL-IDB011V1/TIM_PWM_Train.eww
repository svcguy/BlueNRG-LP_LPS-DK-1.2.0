<workspace>
  <project>
    <path>$WS_DIR$\TIM_PWM_Train.ewp</path>
  </project>
  <batchBuild />
</workspace>