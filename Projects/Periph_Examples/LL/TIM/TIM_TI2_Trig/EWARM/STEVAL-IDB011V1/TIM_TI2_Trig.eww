<workspace>
  <project>
    <path>$WS_DIR$\TIM_TI2_Trig.ewp</path>
  </project>
  <batchBuild />
</workspace>