<workspace>
  <project>
    <path>$WS_DIR$\RTC_WakeUp_Calendar.ewp</path>
  </project>
  <batchBuild />
</workspace>