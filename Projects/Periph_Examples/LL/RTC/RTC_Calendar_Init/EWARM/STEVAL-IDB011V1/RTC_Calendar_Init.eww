<workspace>
  <project>
    <path>$WS_DIR$\RTC_Calendar_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>