<workspace>
  <project>
    <path>$WS_DIR$\RTC_StandbyWakeUpTimer.ewp</path>
  </project>
  <batchBuild />
</workspace>