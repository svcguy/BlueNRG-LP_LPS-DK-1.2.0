<workspace>
  <project>
    <path>$WS_DIR$\RTC_WakeUp.ewp</path>
  </project>
  <batchBuild />
</workspace>