<workspace>
  <project>
    <path>$WS_DIR$\RTC_Alarm_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>