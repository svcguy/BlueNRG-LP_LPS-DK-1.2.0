<workspace>
  <project>
    <path>$WS_DIR$\PDM_DiglMic.ewp</path>
  </project>
  <batchBuild />
</workspace>