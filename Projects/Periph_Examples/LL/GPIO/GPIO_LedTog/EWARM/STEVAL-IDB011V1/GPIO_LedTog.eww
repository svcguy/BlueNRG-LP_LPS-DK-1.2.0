<workspace>
  <project>
    <path>$WS_DIR$\GPIO_LedTog.ewp</path>
  </project>
  <batchBuild />
</workspace>