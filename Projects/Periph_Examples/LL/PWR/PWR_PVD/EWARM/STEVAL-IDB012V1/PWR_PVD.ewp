# IAR project PWR_PVD.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-332 ST BlueNRG-332
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB012V1; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\..\..\Middlewares/ST/hal/Inc; ..\..\..\..\..\..\..\Drivers/BSP/Inc; ..\..\..\..\..\..\..\Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\..\..\..\..\..\..\Drivers/BSP/Components/lps22hh_STdC/driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWR_PVD.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\PWR_PVD.bin"
  ILINK.IlinkOutputFile: PWR_PVD.out
  ILINK.IlinkIcfFile: BlueNRG_LPS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/RF_DRIVER_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_utils.c rf_driver_ll_exti.c rf_driver_ll_pwr.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_io.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Example/User
    ../../Src/: rf_device_it.c PWR_PVD_main.c
