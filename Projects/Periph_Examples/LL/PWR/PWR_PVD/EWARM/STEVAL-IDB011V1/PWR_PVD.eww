<workspace>
  <project>
    <path>$WS_DIR$\PWR_PVD.ewp</path>
  </project>
  <batchBuild />
</workspace>