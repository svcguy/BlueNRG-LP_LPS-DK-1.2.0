<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PKA_ECC_Sign_PKMGR.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



