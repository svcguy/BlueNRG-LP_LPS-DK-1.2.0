<workspace>
  <project>
    <path>$WS_DIR$\PKA_ECC_Sign_PKMGR.ewp</path>
  </project>
  <batchBuild />
</workspace>