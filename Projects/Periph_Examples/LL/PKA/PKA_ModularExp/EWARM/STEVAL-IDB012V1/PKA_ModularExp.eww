<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PKA_ModularExp.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



