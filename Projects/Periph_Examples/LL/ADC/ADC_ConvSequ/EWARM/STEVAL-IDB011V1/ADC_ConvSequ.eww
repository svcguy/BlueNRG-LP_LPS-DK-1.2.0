<workspace>
  <project>
    <path>$WS_DIR$\ADC_ConvSequ.ewp</path>
  </project>
  <batchBuild />
</workspace>