<workspace>
  <project>
    <path>$WS_DIR$\ADC_AnalogMicrophone.ewp</path>
  </project>
  <batchBuild />
</workspace>