<workspace>
  <project>
    <path>$WS_DIR$\ADC_TempSen.ewp</path>
  </project>
  <batchBuild />
</workspace>