<workspace>
  <project>
    <path>$WS_DIR$\ADC_Watchdog.ewp</path>
  </project>
  <batchBuild />
</workspace>