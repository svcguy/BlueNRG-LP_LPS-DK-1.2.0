<workspace>
  <project>
    <path>$WS_DIR$\ADC_BatterySensor.ewp</path>
  </project>
  <batchBuild />
</workspace>