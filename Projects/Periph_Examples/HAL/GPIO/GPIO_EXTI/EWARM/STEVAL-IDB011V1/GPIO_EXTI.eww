<workspace>
  <project>
    <path>$WS_DIR$\GPIO_EXTI.ewp</path>
  </project>
  <batchBuild />
</workspace>