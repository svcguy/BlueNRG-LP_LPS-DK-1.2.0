<workspace>
  <project>
    <path>$WS_DIR$\I2S_CCA01M1_ComIT.ewp</path>
  </project>
  <batchBuild />
</workspace>