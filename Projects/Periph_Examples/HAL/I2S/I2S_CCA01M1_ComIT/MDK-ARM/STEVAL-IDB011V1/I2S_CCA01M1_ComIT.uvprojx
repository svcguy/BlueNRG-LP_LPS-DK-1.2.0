# Keil uVision project I2S_CCA01M1_ComIT.uvprojx, settings and files
target Release (6150000::V6.15::ARMCLANG)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2S_CCA01M1_ComIT +hex
  AfterMake: fromelf.exe --bin Release\Objects\I2S_CCA01M1_ComIT.axf --output Release\Objects\I2S_CCA01M1_ComIT.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c include: ..\..\Inc;..\..\..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\..\..\Drivers/Peripherals_Drivers/inc;..\..\..\..\..\..\..\Drivers/CMSIS/Device/ST/BlueNRG_LP/Include;..\..\..\..\..\..\..\Drivers/CMSIS/Include;..\..\..\..\..\..\..\Drivers/BSP/Inc;..\..\..\..\..\..\..\Drivers/BSP/Components/lsm6dsox_STdC/driver;..\..\..\..\..\..\..\Drivers/BSP/Components/lps22hh_STdC/driver
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Application/User
    ../../Src/: audio_application.c rf_device_hal_msp.c rf_device_it.c cca01m1_audio.c I2S_CCA01M1_ComIT_main.c sta350bw.c sta350bw_reg.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_io.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/src/: rf_driver_hal.c rf_driver_hal_cortex.c rf_driver_hal_dma.c rf_driver_hal_exti.c rf_driver_hal_flash.c rf_driver_hal_flash_ex.c rf_driver_hal_gpio.c rf_driver_hal_i2c.c rf_driver_hal_i2c_ex.c rf_driver_hal_i2s.c rf_driver_hal_pwr.c rf_driver_hal_pwr_ex.c rf_driver_hal_rcc.c rf_driver_hal_rcc_ex.c
