<workspace>
  <project>
    <path>$WS_DIR$\I2S_Receiver.ewp</path>
  </project>
  <batchBuild />
</workspace>