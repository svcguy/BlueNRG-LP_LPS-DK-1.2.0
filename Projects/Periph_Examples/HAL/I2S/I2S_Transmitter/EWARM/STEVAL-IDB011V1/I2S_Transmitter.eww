<workspace>
  <project>
    <path>$WS_DIR$\I2S_Transmitter.ewp</path>
  </project>
  <batchBuild />
</workspace>