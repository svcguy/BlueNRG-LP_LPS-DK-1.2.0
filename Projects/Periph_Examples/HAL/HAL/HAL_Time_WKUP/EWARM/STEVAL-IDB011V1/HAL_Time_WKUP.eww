<workspace>
  <project>
    <path>$WS_DIR$\HAL_Time_WKUP.ewp</path>
  </project>
  <batchBuild />
</workspace>