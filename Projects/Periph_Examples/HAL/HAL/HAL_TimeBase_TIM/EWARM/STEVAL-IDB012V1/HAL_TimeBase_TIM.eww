<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HAL_TimeBase_TIM.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



