<workspace>
  <project>
    <path>$WS_DIR$\HAL_TimeBase_TIM.ewp</path>
  </project>
  <batchBuild />
</workspace>