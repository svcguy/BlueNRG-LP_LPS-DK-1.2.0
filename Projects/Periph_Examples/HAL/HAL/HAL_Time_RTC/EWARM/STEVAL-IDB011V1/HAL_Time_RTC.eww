<workspace>
  <project>
    <path>$WS_DIR$\HAL_Time_RTC.ewp</path>
  </project>
  <batchBuild />
</workspace>