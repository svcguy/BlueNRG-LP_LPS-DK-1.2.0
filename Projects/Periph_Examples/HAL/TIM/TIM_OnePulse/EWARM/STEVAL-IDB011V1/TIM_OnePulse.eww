<workspace>
  <project>
    <path>$WS_DIR$\TIM_OnePulse.ewp</path>
  </project>
  <batchBuild />
</workspace>