<workspace>
  <project>
    <path>$WS_DIR$\TIM_PWMInput.ewp</path>
  </project>
  <batchBuild />
</workspace>