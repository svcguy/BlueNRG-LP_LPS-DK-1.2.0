<workspace>
  <project>
    <path>$WS_DIR$\TIM_OCActive.ewp</path>
  </project>
  <batchBuild />
</workspace>