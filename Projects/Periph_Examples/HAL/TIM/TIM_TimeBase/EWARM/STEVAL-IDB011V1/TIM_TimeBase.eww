<workspace>
  <project>
    <path>$WS_DIR$\TIM_TimeBase.ewp</path>
  </project>
  <batchBuild />
</workspace>