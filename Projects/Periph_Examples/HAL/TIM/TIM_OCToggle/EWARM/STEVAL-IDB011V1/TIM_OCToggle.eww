<workspace>
  <project>
    <path>$WS_DIR$\TIM_OCToggle.ewp</path>
  </project>
  <batchBuild />
</workspace>