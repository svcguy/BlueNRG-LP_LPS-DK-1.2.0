<workspace>
  <project>
    <path>$WS_DIR$\TIM_PWMOutput.ewp</path>
  </project>
  <batchBuild />
</workspace>