<workspace>
  <project>
    <path>$WS_DIR$\TIM_OCInactive.ewp</path>
  </project>
  <batchBuild />
</workspace>