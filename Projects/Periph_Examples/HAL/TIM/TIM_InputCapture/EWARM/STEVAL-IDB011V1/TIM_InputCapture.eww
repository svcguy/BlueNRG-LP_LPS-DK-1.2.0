<workspace>
  <project>
    <path>$WS_DIR$\TIM_InputCapture.ewp</path>
  </project>
  <batchBuild />
</workspace>