<workspace>
  <project>
    <path>$WS_DIR$\CRC_Example.ewp</path>
  </project>
  <batchBuild />
</workspace>