<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C_IT.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>I2C_IT</project>
                <configuration>I2C_IT</configuration>
            </member>
            <member>
                <project>I2C_IT</project>
                <configuration>Master_board</configuration>
            </member>
            <member>
                <project>I2C_IT</project>
                <configuration>Slave_board</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
