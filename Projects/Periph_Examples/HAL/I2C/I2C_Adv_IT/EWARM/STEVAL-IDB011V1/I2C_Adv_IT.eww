<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C_Adv_IT.ewp</path>
    </project>
</workspace>
