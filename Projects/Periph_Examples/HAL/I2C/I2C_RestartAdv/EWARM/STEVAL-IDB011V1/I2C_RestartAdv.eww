<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C_RestartAdv.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>I2C_RestartAdv</project>
                <configuration>I2C_RestartAdv</configuration>
            </member>
            <member>
                <project>I2C_RestartAdv</project>
                <configuration>Master_board</configuration>
            </member>
            <member>
                <project>I2C_RestartAdv</project>
                <configuration>Slave_board</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
