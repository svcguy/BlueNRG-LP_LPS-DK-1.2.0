<workspace>
  <project>
    <path>$WS_DIR$\PKA_ECC_Sign.ewp</path>
  </project>
  <batchBuild />
</workspace>