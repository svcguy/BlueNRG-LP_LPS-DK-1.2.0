<workspace>
  <project>
    <path>$WS_DIR$\UART_HwFlowControl.ewp</path>
  </project>
  <batchBuild />
</workspace>