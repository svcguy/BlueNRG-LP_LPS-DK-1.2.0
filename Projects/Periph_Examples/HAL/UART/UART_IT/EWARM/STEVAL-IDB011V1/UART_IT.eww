<workspace>
  <project>
    <path>$WS_DIR$\UART_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>