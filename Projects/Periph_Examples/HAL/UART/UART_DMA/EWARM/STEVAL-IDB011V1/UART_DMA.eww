<workspace>
  <project>
    <path>$WS_DIR$\UART_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>