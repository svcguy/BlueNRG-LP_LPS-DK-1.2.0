<workspace>
  <project>
    <path>$WS_DIR$\UART_Printf.ewp</path>
  </project>
  <batchBuild />
</workspace>