<workspace>
  <project>
    <path>$WS_DIR$\RTC_Alarm_Polling.ewp</path>
  </project>
  <batchBuild />
</workspace>