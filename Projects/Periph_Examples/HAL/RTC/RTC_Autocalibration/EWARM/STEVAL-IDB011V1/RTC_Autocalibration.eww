<workspace>
  <project>
    <path>$WS_DIR$\RTC_Autocalibration.ewp</path>
  </project>
  <batchBuild />
</workspace>