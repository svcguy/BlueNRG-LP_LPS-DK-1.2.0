<workspace>
  <project>
    <path>$WS_DIR$\RTC_Alarm.ewp</path>
  </project>
  <batchBuild />
</workspace>