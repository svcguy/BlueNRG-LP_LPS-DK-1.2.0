<workspace>
  <project>
    <path>$WS_DIR$\RTC_Calendar.ewp</path>
  </project>
  <batchBuild />
</workspace>