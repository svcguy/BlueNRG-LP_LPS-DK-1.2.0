<workspace>
  <project>
    <path>$WS_DIR$\SPI_IT_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>