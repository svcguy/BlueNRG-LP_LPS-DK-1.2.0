<workspace>
  <project>
    <path>$WS_DIR$\SPI_IT_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>