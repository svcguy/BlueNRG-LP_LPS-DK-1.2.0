<workspace>
  <project>
    <path>$WS_DIR$\SPI_Polling_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>