# IAR project SPI_Polling_Master.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-332 ST BlueNRG-332
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STEVAL_IDB012V1; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers/Peripherals_Drivers/Inc; ..\..\..\..\..\..\..\Drivers/CMSIS/Device/ST/BlueNRG_LP/Include; ..\..\..\..\..\..\..\Drivers/CMSIS/Include; ..\..\..\..\..\..\..\Drivers/BSP/Inc; ..\..\..\..\..\..\..\Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\..\..\..\..\..\..\Drivers/BSP/Components/lps22hh_STdC/driver; ..\..\..\..\..\..\..\Middlewares/ST/hal/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_Polling_Master.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\SPI_Polling_Master.bin"
  ILINK.IlinkOutputFile: SPI_Polling_Master.out
  ILINK.IlinkIcfFile: BlueNRG_LPS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Src/: SPI_Polling_Master_main.c rf_device_it.c rf_device_hal_msp.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_led.c bluenrg_lp_evb_io.c bluenrg_lp_evb_com.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_gpio.c rf_driver_hal_spi.c rf_driver_hal_spi_ex.c rf_driver_hal_rcc.c rf_driver_hal_rcc_ex.c rf_driver_hal_flash.c rf_driver_hal_flash_ex.c rf_driver_hal_dma.c rf_driver_hal_pwr.c rf_driver_hal_pwr_ex.c rf_driver_hal_cortex.c rf_driver_hal.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
