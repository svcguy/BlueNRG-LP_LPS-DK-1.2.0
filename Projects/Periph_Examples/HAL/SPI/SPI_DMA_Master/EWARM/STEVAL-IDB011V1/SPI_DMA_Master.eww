<workspace>
  <project>
    <path>$WS_DIR$\SPI_DMA_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>