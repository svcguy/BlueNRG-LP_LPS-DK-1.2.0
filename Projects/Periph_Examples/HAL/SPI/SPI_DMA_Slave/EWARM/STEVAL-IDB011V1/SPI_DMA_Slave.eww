<workspace>
  <project>
    <path>$WS_DIR$\SPI_DMA_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>