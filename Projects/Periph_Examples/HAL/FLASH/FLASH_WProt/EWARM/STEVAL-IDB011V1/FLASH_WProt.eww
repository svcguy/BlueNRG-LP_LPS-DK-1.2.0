<workspace>
  <project>
    <path>$WS_DIR$\FLASH_WProt.ewp</path>
  </project>
  <batchBuild />
</workspace>