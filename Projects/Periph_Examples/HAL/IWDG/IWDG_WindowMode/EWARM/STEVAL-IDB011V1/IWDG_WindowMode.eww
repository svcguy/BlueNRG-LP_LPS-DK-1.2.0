<workspace>
  <project>
    <path>$WS_DIR$\IWDG_WindowMode.ewp</path>
  </project>
  <batchBuild />
</workspace>