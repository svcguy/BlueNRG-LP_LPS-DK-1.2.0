<workspace>
  <project>
    <path>$WS_DIR$\IWDG_Reset.ewp</path>
  </project>
  <batchBuild />
</workspace>