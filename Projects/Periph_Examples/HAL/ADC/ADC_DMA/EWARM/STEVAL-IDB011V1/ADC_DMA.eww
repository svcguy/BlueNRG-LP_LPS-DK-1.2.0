<workspace>
    <project>
        <path>$WS_DIR$\ADC_DMA.ewp</path>
    </project>
    <batchBuild />
</workspace>
