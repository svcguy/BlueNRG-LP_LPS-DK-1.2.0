<workspace>
  <project>
    <path>$WS_DIR$\RNG_MultiRNG.ewp</path>
  </project>
  <batchBuild />
</workspace>